<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CK_STM32F405(EX-2).ewp</path>
  </project>
  <batchBuild />
</workspace>
