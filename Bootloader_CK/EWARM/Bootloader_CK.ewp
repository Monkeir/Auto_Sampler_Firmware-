# IAR project Bootloader_CK.ewp, settings and files
configuration Bootloader_CK (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F405xx; patterns_stm32f4xx; macroces_stm32f4xx
  ICCARM.CCIncludePath2: ../Inc; ../../STM32Cube_FW_F4_V1.21.0/Drivers/STM32F4xx_HAL_Driver/Inc; ../../STM32Cube_FW_F4_V1.21.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../../STM32Cube_FW_F4_V1.21.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../../STM32Cube_FW_F4_V1.21.0/Drivers/CMSIS/Include; ../../xLibMicrocontrollers/Sources/; ../../xLibMicrocontrollers/Macroces/; ../../xLibMicrocontrollers/Patterns/; ../../xLibMicrocontrollers/Bootloaders/STM32F4xx/; ../../Sources; ../Sources; ../Sources/Interfaces
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Bootloader_CK.hex
  ILINK.IlinkOutputFile: Bootloader_CK.out
  ILINK.IlinkIcfFile: stm32f405xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f405xx.s
  group Application/User
    ../Src/: gpio.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c tim.c usart.c
  group Application/User/Bootloader
    $xLibMicrocontrollers$/Bootloaders/STM32F4xx/: Bootloader.c Bootloader.h Bootloader_Requests.c Bootloader_Requests.h Bootloader_Types.h xFlash.c xFlash.h
  group Application/User/Sources
    ../../Sources/: CK_Ports.c CK_Ports.h
    ../Sources/: Types.h
  group Application/User/xLibMcrocontrollers/Macroces
    $xLibMicrocontrollers$/Macroces/macroces_stm32f4xx/: macroces_stm32f4xx_uart.h
    $xLibMicrocontrollers$/Macroces/: xMacroces.h
  group Application/User/xLibMcrocontrollers/Patterns
    $xLibMicrocontrollers$/Patterns/patterns_stm32f4xx/: pattern_stm32f4xx_timer.c pattern_stm32f4xx_timer.h pattern_stm32f4xx_uart.h
  group Application/User/xLibMcrocontrollers/Sources
    $xLibMicrocontrollers$/Sources/: xConverter.c xConverter.h xList.c xList.h xPort.h xRx.c xRx.h xTask.c xTask.h xThread.c xThread.h xTimer.c xTimer.h xTransaction.c xTransaction.h xTx.c xTx.h xType.h
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    $STM32Cube_FW_F4$/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
