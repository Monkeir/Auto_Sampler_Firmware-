<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Bootloader_CK.ewp</path>
  </project>
  <batchBuild />
</workspace>
